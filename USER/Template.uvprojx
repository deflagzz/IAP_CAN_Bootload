# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: iap +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\FWLIB\STM32F10x_FWLib\inc;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\SRAM;..\MALLOC;..\MALLOC;..\USMART;..\EMWIN\STemWin\Config;..\EMWIN\STemWin\inc;..\EMWIN\Demo;..\HARDWARE\TOUCH;..\EMWIN\Demo;..\SYSTEM\usart;..\SYSTEM\include;..\HARDWARE\DMA;..\HARDWARE\GPS;..\HARDWARE\IR;..\HARDWARE\exti;..\HARDWARE\timer;..\HARDWARE\OLED;..\HARDWARE\CAN;..\HARDWARE\FILTER;..\HARDWARE\LOCK;..\HARDWARE\IAP;..\HARDWARE\STMFLASH;..\HARDWARE;..\HARDWARE\CRC
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ../HARDWARE/: my_include.h
  group HARDWARE
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/IAP/: iap.c
    ../HARDWARE/CRC/: crc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../FWLIB/STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_can.c stm32f10x_flash.c
